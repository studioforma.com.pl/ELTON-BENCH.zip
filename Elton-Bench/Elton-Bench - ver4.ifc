Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Elton-Bench - ver4.ifc
Time: 2025-11-02T23:35:29
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (4)
Name
 | Elton-Bench_0 - ObjectType: SketchupGroup
 | Elton-Bench_1 - ObjectType: SketchupGroup
 | Elton-Bench_2 - ObjectType: SketchupGroup
 | Elton-Bench_3 - ObjectType: SketchupGroup
